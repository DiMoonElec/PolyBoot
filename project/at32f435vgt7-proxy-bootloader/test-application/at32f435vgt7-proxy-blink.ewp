# IAR project at32f435vgt7-proxy-blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F435VGT7_v2 ArteryTek -AT32F435VGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F435VGT7
  ICCARM.CCIncludePath2: ../; ../project/hw_conf/inc/; ../../../hal/at32f435vgt7/CMSIS/inc/; ../../../hal/at32f435vgt7/SPL/inc/; $TOOLKIT_DIR$/CMSIS/Core/Include/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f435vgt7-proxy-bootloader.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: AT32F435VGT7_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: main.c
  group Hardware
    ../project/hw_conf/src/: hw_system_clock.c systick.c
  group CMSIS
    ../../../hal/at32f435vgt7/CMSIS/src/: system_at32f435_437.c startup_at32f435_437.s
  group SPL
    ../../../hal/at32f435vgt7/SPL/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_pwc.c
  group Configuration
    ../: at32f435_437_conf.h
    ./: AT32F435VGT7_APP.icf firmware_version.h
