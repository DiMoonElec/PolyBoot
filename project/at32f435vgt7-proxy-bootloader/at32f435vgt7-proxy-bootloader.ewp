# IAR project at32f435vgt7-proxy-bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F435VGT7_v2 ArteryTek -AT32F435VGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F435VGT7
  ICCARM.CCIncludePath2: ; config/; project/inc/; project/hw_conf/inc/; ../../core/inc/; ../../hal/at32f435vgt7/CMSIS/inc/; ../../hal/at32f435vgt7/SPL/inc/; ../../hal/at32f435vgt7/port/inc/; $TOOLKIT_DIR$/CMSIS/Core/Include/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f435vgt7-proxy-bootloader.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: AT32F435VGT7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    project/src/: bootloader_port.c main.c RingFIFO.c serial_port.c bootloader_proxy_port.c proxy_serial_port.c
  group AT32F435 port
    ../../hal/at32f435vgt7/port/src/: port_application_run.c port_flash.c
  group CMSIS
    ../../hal/at32f435vgt7/CMSIS/src/: startup_at32f435_437.s system_at32f435_437.c
  group Configuration
    ./: at32f435_437_conf.h AT32F435VGT7.icf
    config/: bootloader_project_config.h private_keys.inc
  group Hardware
    project/hw_conf/src/: hw_config.c hw_gpio_config.c hw_interrupts.c hw_uart_config.c hw_system_clock.c systick.c hw_proxy_config.c
  group PolyBoot core
    ../../core/src/: binex-lib.c bootloader.c crc16.c monocypher.c utils.c bootloader_proxy.c
  group SPL
    ../../hal/at32f435vgt7/SPL/src/: at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_usart.c at32f435_437_pwc.c
