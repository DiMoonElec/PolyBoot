<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gd32e230c8-rs485-bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
