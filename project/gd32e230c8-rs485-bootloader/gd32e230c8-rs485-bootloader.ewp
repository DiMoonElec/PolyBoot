# IAR project gd32e230c8-rs485-bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E230x8 GigaDevice GD32E230x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: GD32E230
  ICCARM.CCIncludePath2: ; ../../hal/gd32e230c8/CMSIS/inc/; ../../hal/gd32e230c8/SPL/inc/; ../../hal/gd32e230c8/port/inc/; ../../core/inc/; project/inc/; config/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: GD32E230C8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group CMSIS/inc
    ../../hal/gd32e230c8/CMSIS/inc/: cmsis_compiler.h core_cm23.h gd32e23x.h
  group CMSIS/src
    ../../hal/gd32e230c8/CMSIS/src/: startup_gd32e23x.s
  group core/inc
    ../../core/inc/: binex-lib.h bootloader.h bootloader_port.h crc16.h monocypher.h utils.h
  group core/src
    ../../core/src/: binex-lib.c bootloader.c crc16.c monocypher.c utils.c
  group port/inc
    ../../hal/gd32e230c8/port/inc/: bootloader_hal_config.h
  group port/src
    ../../hal/gd32e230c8/port/src/: port_application_run.c port_flash.c
  group project/inc
    project/inc/: gd32e23x.h gd32e23x_libopt.h port_hardware.h RingFIFO.h serial_port.h systick.h
  group project/src
    project/src/: main.c port_hardware.c RingFIFO.c serial_port.c system_gd32e23x.c systick.c
  group SPL/inc
    ../../hal/gd32e230c8/SPL/inc/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
  group SPL/src
    ../../hal/gd32e230c8/SPL/src/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
