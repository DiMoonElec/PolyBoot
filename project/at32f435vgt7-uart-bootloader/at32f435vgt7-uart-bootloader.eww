<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project><path>$WS_DIR$/at32f435vgt7-uart-bootloader.ewp</path></project>
</workspace>