<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project><path>$WS_DIR$/at32f413cbt7-blink.ewp</path></project>
</workspace>