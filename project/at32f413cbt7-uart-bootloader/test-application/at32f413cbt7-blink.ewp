# IAR project at32f413cbt7-blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413CBT7_v2 ArteryTek -AT32F413CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413CBT7
  ICCARM.CCIncludePath2: ../; ../project/hw_conf/inc/; ../../../hal/at32f413cbt7/CMSIS/inc/; ../../../hal/at32f413cbt7/SPL/inc/; $TOOLKIT_DIR$/CMSIS/Core/Include/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f413cbt7-uart-bootloader.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: AT32F413CBT7_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: main.c
  group Hardware
    ../project/hw_conf/src/: system_clock.c systick.c
  group CMSIS
    ../../../hal/at32f413cbt7/CMSIS/src/: system_at32f413.c startup_at32f413.s
  group SPL
    ../../../hal/at32f413cbt7/SPL/src/: at32f413_crm.c at32f413_gpio.c at32f413_misc.c
  group Configuration
    ../: at32f413_conf.h
    ./: AT32F413CBT7_APP.icf
